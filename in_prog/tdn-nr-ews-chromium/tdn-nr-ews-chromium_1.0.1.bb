SUMMARY = "TDN Epiphany and Psplash"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://${WORKDIR}/files/COPYING;md5=751419260aa954499f7abaabaa882bbe"

