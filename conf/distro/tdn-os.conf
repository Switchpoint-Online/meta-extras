## conf/distro/tdn-os.conf
```bitbake
DISTRO_NAME = "TDN-OS"
DISTRO_VERSION = "3.6 RC6"
DISTRO = "tdn-os"
DISTRO_CODENAME = "tdn"

# Inherit default Poky settings
require conf/distro/poky.conf
```
